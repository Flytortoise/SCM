//完成8个LED灯依次变化的功能
#include<reg52.h>
void ys(void)
{
	unsigned char m,n;
	for(m=0;m<200;m++)
	for(n=0;n<250;n++)
		;
}

void main(void)
{
	unsigned char i;
	unsigned char Tab[] = {0xff,0xfe,0xfd,0xfb,0xf7,
							0xef,0xdf,0xbf,0x7f,0xbf,
							0xdf,0xef,0xf7,0xfb,0xfd,
							0xfe,0xfe,0xfc,0xf8,0xf0,0xe0,0xc0,0x80,0x00,
							0xe7,0xdb,0xbd,0x7e,0x3c,0x18,0x00,0x81,
							0xc3,0xe7,0x7e,0xbd,0xdb,0xe7,0xbd,0xdb};
	unsigned char *p;
	p=Tab;
	while(1)
	{
		for(i=0;i<32;i++)
		{
			P1=*(p+i);
			ys();
		}
	}
}
