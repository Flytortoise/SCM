# Keil uVision project tenplate.uvproj, settings and files
target template (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: tenplate +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\app\inc;.\bsp\inc;.\bsp
  group app
    ./app/: main.c
  group bsp
    ./bsp/: bsp.c
    ./bsp/src/: bsp_work.c bsp_delay.c bsp_int.c bsp_ir.c
